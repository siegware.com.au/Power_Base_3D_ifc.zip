Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T10:54:00
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 150402_PB_XL-120-C
Description: 150402_PB_XL-120-C

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 150402_PB_XL-120-C
Type - PredefinedType: USERDEFINED
Description: Power Base XL 120 C
SHERPA Connection Systems GmbH - Art.-Nr.: 10000026402; Type: Power Base XL 120 C; Steel: S235; Number_of_concrete_anchors: 4; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
