Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T10:52:41
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 150402_PB_XL-95-F
Description: 150402_PB_XL-95-F

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 150402_PB_XL-95-F
Type - PredefinedType: USERDEFINED
Description: Power Base XL 95 F
SHERPA Connection Systems GmbH - Art.-Nr.: 10000027945; Type: Power Base XL 95 F; Steel: S235; Number_of_concrete_anchors: 4; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
