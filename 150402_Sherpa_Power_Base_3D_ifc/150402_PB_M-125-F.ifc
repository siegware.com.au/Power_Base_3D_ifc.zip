Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T10:54:40
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 150402_PB_M-125-F
Description: 150402_PB_M-125-F

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 150402_PB_M-125-F
Type - PredefinedType: USERDEFINED
Description: Power Base M 125 F
SHERPA Connection Systems GmbH - Art.-Nr.: 10000027943; Type: Power Base M 125 F; Steel: S235; Number_of_concrete_anchors: 4; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
