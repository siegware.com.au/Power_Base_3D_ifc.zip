Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T10:54:24
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 150402_PB_XL-140-C
Description: 150402_PB_XL-140-C

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 150402_PB_XL-140-C
Type - PredefinedType: USERDEFINED
Description: Power Base XL 140 C
SHERPA Connection Systems GmbH - Art.-Nr.: 10000028148; Type: Power Base XL 140 C; Steel: S235; Number_of_concrete_anchors: 4; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
